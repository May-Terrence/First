# Keil uVision project ATK-M751.uvprojx, settings and files
target ATK-M751 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: MALLOC +hex
  c flags: Optim=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\SRAM;..\MALLOC;..\FWLIB\inc;..\HARDWARE\ATK-M750;..\HARDWARE\RingBuffer;..\HARDWARE\RS232;..\HARDWARE\RS485;..\HARDWARE\LCD;..\USMART;..\HARDWARE\RTC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/RingBuffer/: RingBuffer.c RingBuffer.h
    ../HARDWARE/ATK-M750/: atk_m750.c atk_m750.h
    ../HARDWARE/RS232/: rs232.c rs232.h
    ../HARDWARE/LCD/: lcd.c lcd.h
    ../HARDWARE/RS485/: rs485.c rs485.h
    ../HARDWARE/RTC/: rtc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_pwr.c
  group MALLOC
    ../MALLOC/: malloc.c
  group README
    ../: readme.txt
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
